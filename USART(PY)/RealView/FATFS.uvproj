# Keil uVision project FATFS.uvproj, settings and files
target STM32-SDCard-SDIO (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_FD_SDCard-SDIO +hex
  c flags: Optim=1 OneElfS=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\FWlib\inc;..\user;..\fatfs;..\fatfs;..\CMSIS;..\driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../user/: main.c
  group StdPeriph_Driver
    ../FWlib/SRC/: stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_fsmc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_wwdg.c
  group RVMDK
    ../startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: system_stm32f10x.c core_cm3.c stm32f10x_it.c
  group driver
    ../driver/: HardInit.c OSQMem.c PinYin.c PinYinIndex.c USART1.c USART1ConFig.c
